# Keil uVision project HUST RM .uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HUST RM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx, ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\User;..\Mylib;..\Library\CMSIS;..\Library\inc;..\Library\src;..\Task;..\Mylib;..\FreeRTOS\src;..\FreeRTOS\port\MemMang;..\FreeRTOS\port\RVDS\ARM_CM4F;..\FreeRTOS\include;..\DataHandle;..\Assist;..\parts;..\DSP_LIB\Include;..\DSP_LIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c system_stm32f4xx.c stm32f4xx_it.c FreeRTOSConfig.h readme.txt Communication.c
    ../Assist/: arm_cortexM4lf_math.lib
    ../Library/src/: stm32f4xx_iwdg.c
  group Mylib
    ../Mylib/: can1.c can2.c tim.c tim7.c KalmanFilter.c algorithmOfCRC.c iwdg.c SteeringEngine.c usart3.c uart5.c LED.c laser.c
    ./: Trajector_Equ.c
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c
    ../Library/CMSIS/: startup_stm32f40_41xxx.s
  group Task
    ../Task/: Start_Task.c GimbalTask.c ZeroCheckTask.c ActionControlTask.c ShootTask.c ChassisTask.c LED_Task.c
  group FreeRTOS/Src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group DataHandle
    ../DataHandle/: CANReceiveTask.c CANSendTask.c DataReceiveTask.c
  group Assist
    ../Assist/: DataScope_DP.C pid.c
  group parts
    ../parts/: Remote.c Gyro.c
